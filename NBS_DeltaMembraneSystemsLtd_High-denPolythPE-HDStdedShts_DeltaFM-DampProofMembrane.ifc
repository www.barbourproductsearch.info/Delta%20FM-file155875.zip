Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-10-15T11:03:44
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Basic Wall:NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaFM-DampProofMembrane, Basic Wall:NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaFM-DampProofMembrane:222059
In: Level 0
Type - PredefinedType: MEMBRANE; Material: NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaFM-DampProofMembrane 4 mm
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: MEMBRANE
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_57_51_36: High-density polyethylene (PE-HD) studded sheets; Color: n/a; Finish: n/a; Material: High density polyethylene (HDPE); Shape: Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: A studded membrane designed to combat dampness and contamination in floor applications.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Delta FM - Damp Proof Membrane; Name: High-densityPolyethylenePE-HDStuddedSheets_DeltaFM-DampProofMembrane_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaFM-DampProofMembrane; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/dac0278d-8682-29d5-3bcd-57eea7ad7c87/108276e7-fef8-43b0-bc61-d697cf3a9097; Uniclass2015Code: Pr_25_57_51_36; Uniclass2015Title: High-density polyethylene (PE-HD) studded sheets; Uniclass2015Version: Products v1.35; Version: 5
Type - NBS_Data - Standard: To BS 8102:2022; Third-partyCertification: BBA Agrément Certificate 00/3742, Product Sheet 4; StudHeight: 3 mm; SheetThickness: 0.6 mm; WeightMinimum: 0.5 kg/m²; Colour: Brown; RecycledContent: 0; ContainsRedListMaterials: No; CountryOfProductManufacture: Germany; Material: High density polyethylene (HDPE); Recyclability: Yes; DeltaTape: Required,Not required; Membrane: 0.6 mm; CompressiveStrength: 140 kN/m²; RollSize: 20 x 2 m
Classification: Pr_25_57_51_36 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaFM-DampProofMembrane, Floor:NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaFM-DampProofMembrane:221901
In: Level 0
Type - PredefinedType: MEMBRANE; Material: NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaFM-DampProofMembrane 4 mm
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: MEMBRANE
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_57_51_36: High-density polyethylene (PE-HD) studded sheets; Color: n/a; Finish: n/a; Material: High density polyethylene (HDPE); Shape: Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: A studded membrane designed to combat dampness and contamination in floor applications.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Delta FM - Damp Proof Membrane; Name: High-densityPolyethylenePE-HDStuddedSheets_DeltaFM-DampProofMembrane_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_High-densityPolyethylenePE-HDStuddedSheets_DeltaFM-DampProofMembrane; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/dac0278d-8682-29d5-3bcd-57eea7ad7c87/3f8ad1be-2fbd-49d7-b2e5-edceebbf2d46; Uniclass2015Code: Pr_25_57_51_36; Uniclass2015Title: High-density polyethylene (PE-HD) studded sheets; Uniclass2015Version: Products v1.35; Version: 4
Type - NBS_Data - Standard: To BS 8102:2022; Third-partyCertification: BBA Agrément Certificate 00/3742, Product Sheet 4; StudHeight: 3 mm; SheetThickness: 0.6 mm; WeightMinimum: 0.5 kg/m²; Colour: Brown; RecycledContent: 0; ContainsRedListMaterials: No; CountryOfProductManufacture: Germany; Material: High density polyethylene (HDPE); Recyclability: Yes; DeltaTape: Required,Not required; Membrane: 0.6 mm; CompressiveStrength: 140 kN/m²; RollSize: 20 x 2 m
Classification: Pr_25_57_51_36 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
